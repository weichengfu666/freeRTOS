# Keil uVision project fw_exti.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fw_exti +hex
  AfterMake: D:\sofeware\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\..\Output\fw_exti.bin ..\..\Output\fw_exti.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Drivers\CMSIS;..\..\Drivers\STM32F1xx_HAL_Driver\inc;..\..\Drivers;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: stm32f10x_it.c main_RTOS.c
    ../../Drivers/CMSIS/: system_stm32f10x.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/src/: led.c
    ../../Drivers/BSP/KEY/src/: key.c
    ../../Drivers/BSP/BEEP/src/: beep.c
    ../../Drivers/BSP/EXTI/src/: exti.c
    ../../Drivers/SYSTEM/USART/src/: usart.c
    ../../Drivers/BSP/ESP32/src/: esp.c
    ../../Drivers/BSP/DHT11/src/: dht11.c
    ../../Drivers/BSP/TIMER/src/: timer.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/DELAY/src/: delay.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../../Drivers/CMSIS/startup/: startup_stm32f10x_hd.s
